# IAR project hplRTOS_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\My_Embedded\Micontroller\hplRTOS_STM32F1\include; D:\My_Embedded\Micontroller\Stm32f10x\include; D:\My_Embedded\Micontroller\hplRTOS_STM32F1\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: hplRTOS_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../Stm32f10x/source/: gpio.c systick.c
    ../../src/: hplRTOS.c mutex.c queue.c semaphore.c startup_stm32f103cx.s switch.s
    ../../example/: mutex_test.c
